/*
 * M5Stack Cardputer display - see cardputer_display.h
 */

#include "cardputer_display.h"
#include "cardputer_battery.h"

#include <stdio.h>
#include <string.h>

#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"
#include "freertos/task.h"
#include "driver/gpio.h"
#include "driver/spi_master.h"
#include "esp_heap_caps.h"
#include "esp_lcd_panel_io.h"
#include "esp_lcd_panel_ops.h"
#include "esp_lcd_panel_vendor.h"
#include "esp_log.h"

static const char *TAG = "display";

#define LCD_MOSI_PIN 35 // DATA
#define LCD_SCLK_PIN 36 // SCK
#define LCD_CS_PIN 37   // CS
#define LCD_DC_PIN 34   // RS/DC
#define LCD_RST_PIN 33  // RST
#define LCD_BL_PIN 38   // backlight
#define LCD_PIXEL_CLK 40000000

static esp_lcd_panel_io_handle_t lcd_io_handle = NULL;
static esp_lcd_panel_handle_t lcd_panel_handle = NULL;
static SemaphoreHandle_t display_mutex = NULL; // recursive, guards framebuffer and backlight
static uint16_t *framebuffer = NULL;           // 240x136, landscape

/* 8x8 font, ASCII 32-127 (bit 0 = leftmost pixel) */
static const uint8_t font8x8[96][8] = {
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}, // space
    {0x18, 0x3C, 0x3C, 0x18, 0x18, 0x00, 0x18, 0x00}, // !
    {0x36, 0x36, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}, // "
    {0x36, 0x36, 0x7F, 0x36, 0x7F, 0x36, 0x36, 0x00}, // #
    {0x0C, 0x3E, 0x03, 0x1E, 0x30, 0x1F, 0x0C, 0x00}, // $
    {0x00, 0x63, 0x33, 0x18, 0x0C, 0x66, 0x63, 0x00}, // %
    {0x1C, 0x36, 0x1C, 0x6E, 0x3B, 0x33, 0x6E, 0x00}, // &
    {0x06, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00}, // '
    {0x18, 0x0C, 0x06, 0x06, 0x06, 0x0C, 0x18, 0x00}, // (
    {0x06, 0x0C, 0x18, 0x18, 0x18, 0x0C, 0x06, 0x00}, // )
    {0x00, 0x66, 0x3C, 0xFF, 0x3C, 0x66, 0x00, 0x00}, // *
    {0x00, 0x0C, 0x0C, 0x3F, 0x0C, 0x0C, 0x00, 0x00}, // +
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x06}, // ,
    {0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00}, // -
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00}, // .
    {0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00}, // /
    {0x3E, 0x63, 0x73, 0x7B, 0x6F, 0x67, 0x3E, 0x00}, // 0
    {0x0C, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x3F, 0x00}, // 1
    {0x1E, 0x33, 0x30, 0x1C, 0x06, 0x33, 0x3F, 0x00}, // 2
    {0x1E, 0x33, 0x30, 0x1C, 0x30, 0x33, 0x1E, 0x00}, // 3
    {0x38, 0x3C, 0x36, 0x33, 0x7F, 0x30, 0x78, 0x00}, // 4
    {0x3F, 0x03, 0x1F, 0x30, 0x30, 0x33, 0x1E, 0x00}, // 5
    {0x1C, 0x06, 0x03, 0x1F, 0x33, 0x33, 0x1E, 0x00}, // 6
    {0x3F, 0x33, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x00}, // 7
    {0x1E, 0x33, 0x33, 0x1E, 0x33, 0x33, 0x1E, 0x00}, // 8
    {0x1E, 0x33, 0x33, 0x3E, 0x30, 0x18, 0x0E, 0x00}, // 9
    {0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00}, // :
    {0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x06}, // ;
    {0x18, 0x0C, 0x06, 0x03, 0x06, 0x0C, 0x18, 0x00}, // <
    {0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00}, // =
    {0x06, 0x0C, 0x18, 0x30, 0x18, 0x0C, 0x06, 0x00}, // >
    {0x1E, 0x33, 0x30, 0x18, 0x0C, 0x00, 0x0C, 0x00}, // ?
    {0x3E, 0x63, 0x7B, 0x7B, 0x7B, 0x03, 0x1E, 0x00}, // @
    {0x0C, 0x1E, 0x33, 0x33, 0x3F, 0x33, 0x33, 0x00}, // A
    {0x3F, 0x66, 0x66, 0x3E, 0x66, 0x66, 0x3F, 0x00}, // B
    {0x3C, 0x66, 0x03, 0x03, 0x03, 0x66, 0x3C, 0x00}, // C
    {0x1F, 0x36, 0x66, 0x66, 0x66, 0x36, 0x1F, 0x00}, // D
    {0x7F, 0x46, 0x16, 0x1E, 0x16, 0x46, 0x7F, 0x00}, // E
    {0x7F, 0x46, 0x16, 0x1E, 0x16, 0x06, 0x0F, 0x00}, // F
    {0x3C, 0x66, 0x03, 0x03, 0x73, 0x66, 0x7C, 0x00}, // G
    {0x33, 0x33, 0x33, 0x3F, 0x33, 0x33, 0x33, 0x00}, // H
    {0x1E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1E, 0x00}, // I
    {0x78, 0x30, 0x30, 0x30, 0x33, 0x33, 0x1E, 0x00}, // J
    {0x67, 0x66, 0x36, 0x1E, 0x36, 0x66, 0x67, 0x00}, // K
    {0x0F, 0x06, 0x06, 0x06, 0x46, 0x66, 0x7F, 0x00}, // L
    {0x63, 0x77, 0x7F, 0x7F, 0x6B, 0x63, 0x63, 0x00}, // M
    {0x63, 0x67, 0x6F, 0x7B, 0x73, 0x63, 0x63, 0x00}, // N
    {0x1C, 0x36, 0x63, 0x63, 0x63, 0x36, 0x1C, 0x00}, // O
    {0x3F, 0x66, 0x66, 0x3E, 0x06, 0x06, 0x0F, 0x00}, // P
    {0x1E, 0x33, 0x33, 0x33, 0x3B, 0x1E, 0x38, 0x00}, // Q
    {0x3F, 0x66, 0x66, 0x3E, 0x36, 0x66, 0x67, 0x00}, // R
    {0x1E, 0x33, 0x07, 0x0E, 0x38, 0x33, 0x1E, 0x00}, // S
    {0x3F, 0x2D, 0x0C, 0x0C, 0x0C, 0x0C, 0x1E, 0x00}, // T
    {0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x00}, // U
    {0x33, 0x33, 0x33, 0x33, 0x33, 0x1E, 0x0C, 0x00}, // V
    {0x63, 0x63, 0x63, 0x6B, 0x7F, 0x77, 0x63, 0x00}, // W
    {0x63, 0x63, 0x36, 0x1C, 0x1C, 0x36, 0x63, 0x00}, // X
    {0x33, 0x33, 0x33, 0x1E, 0x0C, 0x0C, 0x1E, 0x00}, // Y
    {0x7F, 0x63, 0x31, 0x18, 0x4C, 0x66, 0x7F, 0x00}, // Z
    {0x1E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x1E, 0x00}, // [
    {0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x00}, // backslash
    {0x1E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1E, 0x00}, // ]
    {0x08, 0x1C, 0x36, 0x63, 0x00, 0x00, 0x00, 0x00}, // ^
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF}, // _
    {0x0C, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00}, // `
    {0x00, 0x00, 0x1E, 0x30, 0x3E, 0x33, 0x6E, 0x00}, // a
    {0x07, 0x06, 0x06, 0x3E, 0x66, 0x66, 0x3B, 0x00}, // b
    {0x00, 0x00, 0x1E, 0x33, 0x03, 0x33, 0x1E, 0x00}, // c
    {0x38, 0x30, 0x30, 0x3e, 0x33, 0x33, 0x6E, 0x00}, // d
    {0x00, 0x00, 0x1E, 0x33, 0x3f, 0x03, 0x1E, 0x00}, // e
    {0x1C, 0x36, 0x06, 0x0f, 0x06, 0x06, 0x0F, 0x00}, // f
    {0x00, 0x00, 0x6E, 0x33, 0x33, 0x3E, 0x30, 0x1F}, // g
    {0x07, 0x06, 0x36, 0x6E, 0x66, 0x66, 0x67, 0x00}, // h
    {0x0C, 0x00, 0x0E, 0x0C, 0x0C, 0x0C, 0x1E, 0x00}, // i
    {0x30, 0x00, 0x30, 0x30, 0x30, 0x33, 0x33, 0x1E}, // j
    {0x07, 0x06, 0x66, 0x36, 0x1E, 0x36, 0x67, 0x00}, // k
    {0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1E, 0x00}, // l
    {0x00, 0x00, 0x33, 0x7F, 0x7F, 0x6B, 0x63, 0x00}, // m
    {0x00, 0x00, 0x1F, 0x33, 0x33, 0x33, 0x33, 0x00}, // n
    {0x00, 0x00, 0x1E, 0x33, 0x33, 0x33, 0x1E, 0x00}, // o
    {0x00, 0x00, 0x3B, 0x66, 0x66, 0x3E, 0x06, 0x0F}, // p
    {0x00, 0x00, 0x6E, 0x33, 0x33, 0x3E, 0x30, 0x78}, // q
    {0x00, 0x00, 0x3B, 0x6E, 0x66, 0x06, 0x0F, 0x00}, // r
    {0x00, 0x00, 0x3E, 0x03, 0x1E, 0x30, 0x1F, 0x00}, // s
    {0x08, 0x0C, 0x3E, 0x0C, 0x0C, 0x2C, 0x18, 0x00}, // t
    {0x00, 0x00, 0x33, 0x33, 0x33, 0x33, 0x6E, 0x00}, // u
    {0x00, 0x00, 0x33, 0x33, 0x33, 0x1E, 0x0C, 0x00}, // v
    {0x00, 0x00, 0x63, 0x6B, 0x7F, 0x7F, 0x36, 0x00}, // w
    {0x00, 0x00, 0x63, 0x36, 0x1C, 0x36, 0x63, 0x00}, // x
    {0x00, 0x00, 0x33, 0x33, 0x33, 0x3E, 0x30, 0x1F}, // y
    {0x00, 0x00, 0x3F, 0x19, 0x0C, 0x26, 0x3F, 0x00}, // z
    {0x38, 0x0C, 0x0C, 0x07, 0x0C, 0x0C, 0x38, 0x00}, // {
    {0x18, 0x18, 0x18, 0x00, 0x18, 0x18, 0x18, 0x00}, // |
    {0x07, 0x0C, 0x0C, 0x38, 0x0C, 0x0C, 0x07, 0x00}, // }
    {0x6E, 0x3B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}, // ~
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}  // del
};

/* Arrows at their CP437 codes: 0x18 up, 0x19 down, 0x1A right, 0x1B left */
static const uint8_t arrow_glyphs[4][8] = {
    {0x18, 0x3C, 0x7E, 0x18, 0x18, 0x18, 0x18, 0x00}, // up
    {0x18, 0x18, 0x18, 0x18, 0x7E, 0x3C, 0x18, 0x00}, // down
    {0x10, 0x30, 0x70, 0x7F, 0x7F, 0x70, 0x30, 0x10}, // right
    {0x04, 0x06, 0x07, 0x7F, 0x7F, 0x07, 0x06, 0x04}, // left
};

bool lcd_init(void)
{
  if (!display_mutex)
    display_mutex = xSemaphoreCreateRecursiveMutex();

  // Backlight off until the first screen is drawn
  gpio_config_t bk_gpio_config = {};
  bk_gpio_config.pin_bit_mask = 1ULL << LCD_BL_PIN;
  bk_gpio_config.mode = GPIO_MODE_OUTPUT;
  gpio_config(&bk_gpio_config);
  gpio_set_level((gpio_num_t)LCD_BL_PIN, 0);

  spi_bus_config_t buscfg = {};
  buscfg.mosi_io_num = LCD_MOSI_PIN;
  buscfg.miso_io_num = -1;
  buscfg.sclk_io_num = LCD_SCLK_PIN;
  buscfg.quadwp_io_num = -1;
  buscfg.quadhd_io_num = -1;
  buscfg.max_transfer_sz = LCD_H_RES * LCD_V_RES * sizeof(uint16_t);
  ESP_ERROR_CHECK(spi_bus_initialize(SPI2_HOST, &buscfg, SPI_DMA_CH_AUTO));

  esp_lcd_panel_io_spi_config_t io_config = {};
  io_config.cs_gpio_num = LCD_CS_PIN;
  io_config.dc_gpio_num = LCD_DC_PIN;
  io_config.spi_mode = 0;
  io_config.pclk_hz = LCD_PIXEL_CLK;
  io_config.trans_queue_depth = 10;
  io_config.lcd_cmd_bits = 8;
  io_config.lcd_param_bits = 8;
  ESP_ERROR_CHECK(esp_lcd_new_panel_io_spi((esp_lcd_spi_bus_handle_t)SPI2_HOST, &io_config, &lcd_io_handle));

  esp_lcd_panel_dev_config_t panel_config = {};
  panel_config.reset_gpio_num = LCD_RST_PIN;
  panel_config.rgb_ele_order = LCD_RGB_ELEMENT_ORDER_BGR;
  panel_config.bits_per_pixel = 16;
  ESP_ERROR_CHECK(esp_lcd_new_panel_st7789(lcd_io_handle, &panel_config, &lcd_panel_handle));

  esp_lcd_panel_reset(lcd_panel_handle);
  vTaskDelay(pdMS_TO_TICKS(100));
  esp_lcd_panel_init(lcd_panel_handle);
  vTaskDelay(pdMS_TO_TICKS(100));

  // ST7789V2 of the Cardputer: inverted colors, 135x240 window at (52, 40),
  // landscape (swapped and mirrored)
  esp_lcd_panel_invert_color(lcd_panel_handle, true);
  esp_lcd_panel_set_gap(lcd_panel_handle, 40, 52);
  esp_lcd_panel_swap_xy(lcd_panel_handle, true);
  esp_lcd_panel_mirror(lcd_panel_handle, true, false);
  esp_lcd_panel_disp_on_off(lcd_panel_handle, true);
  vTaskDelay(pdMS_TO_TICKS(100));

  framebuffer = (uint16_t *)heap_caps_malloc(LCD_V_RES * LCD_H_RES * sizeof(uint16_t), MALLOC_CAP_DMA);
  if (!framebuffer)
  {
    ESP_LOGE(TAG, "Failed to allocate the framebuffer");
    return false;
  }
  ESP_LOGI(TAG, "Display ready: %dx%d", LCD_V_RES, LCD_H_RES);
  return true;
}

bool lcd_ready(void) { return framebuffer != NULL; }

void display_lock(void)
{
  if (display_mutex)
    xSemaphoreTakeRecursive(display_mutex, portMAX_DELAY);
}

void display_unlock(void)
{
  if (display_mutex)
    xSemaphoreGiveRecursive(display_mutex);
}

void lcd_backlight(bool on) { gpio_set_level((gpio_num_t)LCD_BL_PIN, on ? 1 : 0); }

void lcd_flush(void)
{
  if (!lcd_panel_handle || !framebuffer)
    return;
  esp_lcd_panel_draw_bitmap(lcd_panel_handle, 0, 0, LCD_V_RES, LCD_H_RES, framebuffer);
}

void lcd_fill_screen(uint16_t color)
{
  if (!framebuffer)
    return;
  for (int i = 0; i < LCD_V_RES * LCD_H_RES; i++)
    framebuffer[i] = color;
}

void lcd_fill_rect(int x, int y, int w, int h, uint16_t color)
{
  if (!framebuffer)
    return;
  int x0 = x < 0 ? 0 : x;
  int y0 = y < 0 ? 0 : y;
  int x1 = x + w > LCD_V_RES ? LCD_V_RES : x + w;
  int y1 = y + h > LCD_H_RES ? LCD_H_RES : y + h;
  for (int py = y0; py < y1; py++)
    for (int px = x0; px < x1; px++)
      framebuffer[py * LCD_V_RES + px] = color;
}

void lcd_fill_circle(int x, int y, int radius, uint16_t color)
{
  if (!framebuffer)
    return;
  for (int dy = -radius; dy <= radius; dy++)
    for (int dx = -radius; dx <= radius; dx++)
      if (dx * dx + dy * dy <= radius * radius && x + dx >= 0 && x + dx < LCD_V_RES && y + dy >= 0 &&
          y + dy < LCD_H_RES)
        framebuffer[(y + dy) * LCD_V_RES + (x + dx)] = color;
}

void lcd_draw_char(int x, int y, char c, uint16_t color, uint16_t bg_color)
{
  const uint8_t *glyph;
  if (c >= 0x18 && c <= 0x1B)
    glyph = arrow_glyphs[c - 0x18];
  else if (c >= 32 && c <= 127)
    glyph = font8x8[c - 32];
  else
    return;
  if (!framebuffer)
    return;

  for (int py = 0; py < FONT_H; py++)
  {
    uint8_t line = glyph[py];
    for (int px = 0; px < FONT_W; px++)
    {
      int screen_x = x + px;
      int screen_y = y + py;
      if (screen_x >= 0 && screen_x < LCD_V_RES && screen_y >= 0 && screen_y < LCD_H_RES)
        framebuffer[screen_y * LCD_V_RES + screen_x] = (line & (1 << px)) ? color : bg_color;
    }
  }
}

void lcd_draw_string(int x, int y, const char *str, uint16_t color, uint16_t bg_color)
{
  for (; *str; str++, x += FONT_W)
    lcd_draw_char(x, y, *str, color, bg_color);
}

/* ═══════════════════════════════════════════════════════════════════
 * Widgets
 * ═══════════════════════════════════════════════════════════════════ */

void ui_draw_frame(int x, int y, int w, int h)
{
  lcd_fill_rect(x, y, w, 1, THEME_BORDER);
  lcd_fill_rect(x, y + h - 1, w, 1, THEME_BORDER);
  lcd_fill_rect(x, y, 1, h, THEME_BORDER);
  lcd_fill_rect(x + w - 1, y, 1, h, THEME_BORDER);
}

void ui_draw_title_bar(const char *title)
{
  lcd_fill_rect(0, 0, LCD_V_RES, 18, THEME_BAR);
  lcd_draw_string(5, 5, title, THEME_TITLE, THEME_BAR);
  ui_draw_battery(236, 4, THEME_BAR);
}

void ui_draw_battery(int right_x, int y, uint16_t bg_color)
{
  int level = battery_percent();
  if (level < 0)
    return;
  uint16_t color = level <= 15 ? THEME_ERROR : THEME_OK; // red when low

  // 18x9 outline with a 2x5 terminal on the right
  int x = right_x - 20;
  lcd_fill_rect(x, y, 18, 9, color);
  lcd_fill_rect(x + 1, y + 1, 16, 7, bg_color);
  lcd_fill_rect(x + 18, y + 2, 2, 5, color);
  lcd_fill_rect(x + 2, y + 2, 14 * level / 100, 5, color);

  char text[12];
  snprintf(text, sizeof(text), "%d%%", level);
  lcd_draw_string(x - 4 - (int)strlen(text) * FONT_W, y + 1, text, color, bg_color);
}

void ui_draw_signal_bars(int x, int y, int rssi)
{
  int bars = 1;
  if (rssi > -70)
    bars = 4;
  else if (rssi > -80)
    bars = 3;
  else if (rssi > -90)
    bars = 2;

  // Heights 2, 4, 6, 8, aligned at the bottom
  for (int i = 0; i < 4; i++)
  {
    int bar_height = 2 + i * 2;
    lcd_fill_rect(x + i * 4, y + 8 - bar_height, 3, bar_height, i < bars ? THEME_OK : GRUV_BG2);
  }
}

void ui_draw_rssi_meter(int x, int y, int w, int h, int rssi, uint16_t color)
{
  int level = rssi + 100; // -100 dBm = empty, -30 dBm = full
  level = level < 0 ? 0 : (level > 70 ? 70 : level);
  ui_draw_frame(x, y, w, h);
  lcd_fill_rect(x + 1, y + 1, w - 2, h - 2, THEME_BG);
  lcd_fill_rect(x + 2, y + 2, (w - 4) * level / 70, h - 4, color);
}
